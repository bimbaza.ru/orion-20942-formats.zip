Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:44+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-SP1B-M-83
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-SP1B-M-83 Скамья парковая ОС-1 · мрамор «шахматка»
In: Площадка
Description: Изделие бетонное благоустройства. Скамья парковая ОС-1 · мрамор «шахматка»; Classification: 59.1.15.01-1076 Скамья (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SP1B-M-83; ModelReference: Скамья парковая ОС-1 · мрамор «шахматка»; ProductionYear: 2026; ArticleNumber: ZSK-SP1B-M-83
ORION_Изделие - Артикул: ZSK-SP1B-M-83; Артикул прежний: SD-SP1B-M-83; Наименование: Скамья парковая ОС-1 · мрамор «шахматка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 2300×400×420 мм; Материал: Бетон; Цена: 66 800 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20942; Код КСИ: CPr>EDD070; Класс КСИ: Скамья; Коды КСР: 59.1.15.01-1076 … 59.1.15.02-0539
ADSK - ADSK_Наименование: Скамья парковая ОС-1 · мрамор «шахматка»; ADSK_Марка: ZSK-SP1B-M-83; ADSK_Код изделия: 59.1.15.01-1076; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20942
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD070; ZSK_Артикул_прежний: SD-SP1B-M-83
Qto_ORION - Длина: 2300 mm; Ширина: 400 mm; Высота: 420 mm
